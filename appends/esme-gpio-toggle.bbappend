inherit externalsrc
EXTERNALSRC = "/home/invite/w/src/esme-G5/esme-G5-gpio-toggle"
EXTERNALSRC_BUILD = "/home/invite/w/src/esme-G5/esme-G5-gpio-toggle"
